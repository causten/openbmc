LINUX_VERSION_EXTENSION = "-palmetto"

COMPATIBLE_MACHINE = "palmetto"

KERNEL_DEFCONFIG_aspeed = "wedge_defconfig"
